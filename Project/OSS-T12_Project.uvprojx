# Keil uVision project OSS-T12_Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32F003x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.3
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) IROM2(0x1FFF0E80,0x00000010) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: OSS-T210_Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,PY32F003x8,ARM_MATH_CM0PLUS
  c include: ..\BSP;..\CMSIS;..\Hardware;..\PY32F0xx_HAL_Driver\Inc;..\SoftWare;..\System;..\User;..\Drive
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT5: ROM 0x1fff0e80 size 0x10
  memory RVCT9: RAM 0x20000000 size 0x2000
  group BSP
    ../BSP/: py32f003xx_Start_Kit.c
  group Drive
    ../Drive/: Drive_adc.c Drive_clock.c Drive_uart.c Drive_Button.c Drive_Buz.c Drive_Encoder.c Drive_MosSwitch.c Drive_DesplayLcd.c Drive_BackLed.c Drive_Iwdg.c Drive_flash.c
  group HalLib
    ../PY32F0xx_HAL_Driver/Src/: py32f0xx_hal.c py32f0xx_hal_adc.c py32f0xx_hal_comp.c py32f0xx_hal_cortex.c py32f0xx_hal_crc.c py32f0xx_hal_dma.c py32f0xx_hal_exti.c py32f0xx_hal_flash.c py32f0xx_hal_gpio.c py32f0xx_hal_i2c.c py32f0xx_hal_irda.c py32f0xx_hal_iwdg.c py32f0xx_hal_led.c py32f0xx_hal_lptim.c py32f0xx_hal_pwr.c py32f0xx_hal_rcc.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_rtc.c py32f0xx_hal_rtc_ex.c py32f0xx_hal_spi.c py32f0xx_hal_tim.c py32f0xx_hal_tim_ex.c py32f0xx_hal_uart.c py32f0xx_hal_usart.c py32f0xx_hal_wwdg.c
  group SoftWare
    ../SoftWare/: APP_displayLcd.c APP_TimeSlice.c APP_pid.c APP_math.c APP_Coder.c APP_HCI.c APP_BuzMusic.c
  group System
    ../System/: py32f0xx_hal_msp.c py32f0xx_it.c system_py32f0xx.c startup_py32f003xx.s
  group User
    ../User/: main.c
  group CMSIS
    ../CMSIS/: arm_fir_f32.c
